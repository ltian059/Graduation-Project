# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x10000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TARGET=MAX32665,TARGET_REV=0x4131,EXT_FLASH_MX25,
  c include: .\headers
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:GPIO:Custom 1.0.0, CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS Driver:USB Host:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:I2C:Multi-Slave 1.0.1, CMSIS Driver:NAND:Memory Bus 1.1.0, CMSIS Driver:SPI:Multi-Slave 1.0.1, BSP:EvKit V1 1.1.0, Device:ADC 1.1.0, Device:CORE1 1.1.0, Device:DMA 1.1.0, Device:FLC 1.1.0, Device:GPIO 1.1.0, Device:HTMR 1.1.0, Device:I2C 1.1.0, Device:Low Power 1.1.0, Device:OWM 1.1.0, Device:SYS 1.1.0, Device:Startup 1.1.0, Device:Timers 1.1.0, Device:UART 1.1.0, Misc Drivers:Temp Sensor 1.1.0
