# Keil uVision project pro3.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x10000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TARGET=MAX32665 TARGET_REV=0x4131 EXT_FLASH_MX25
  c include: ..\TEST3;.\Headers
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c algohub_api.c algohub_config_api.c sh_comm.c i2c_ah_sh_api.c demo.c sensorhub_api.c sensorhub_config_api.c
  group Headers
    ./Headers/: i2c_ah_sh_api.h algohub_api.h algohub_config_api.h config.h sensorhub_api.h sensorhub_config_api.h sh_comm.h
software components: CMSIS:CORE 6.1.0, BSP:EvKit V1 1.1.0, Device:DMA 1.1.0, Device:FLC 1.1.0, Device:GPIO 1.1.0, Device:I2C 1.1.0, Device:SPIXF 1.1.0, Device:SYS 1.1.0, Device:Startup 1.1.0, Device:TPU 1.1.0, Device:UART 1.1.0
