# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32665 Maxim MAX32665
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TARGET=MAX32665; TARGET_REV=0x4131
  ICCARM.PreInclude: D:\OneDrive\Desktop\Graduate Project\embeded_code\mxc_config.h
  ICCARM.CCIncludePath2: D:\OneDrive\Desktop\Graduate Project\msdk-main\Libraries\PeriphDrivers\Include\MAX32665; D:\OneDrive\Desktop\Graduate Project\msdk-main\Libraries\CMSIS\Device\Maxim\MAX32665\Include; D:\OneDrive\Desktop\Graduate Project\msdk-main\Libraries\CMSIS\Include; D:\OneDrive\Desktop\Graduate Project\msdk-main\Libraries\FreeRTOS\Source\include; D:\OneDrive\Desktop\Graduate Project\embeded_code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Analog/maxrefdes104_eval_package_v1.2.001/MAX32666_Microcontroller_Host_Example_Src_Code/: algohub_api.c algohub_config_api.c demo.c i2c_ah_sh_api.c sensorhub_api.c sensorhub_config_api.c sh_comm.c
    ./: main.c
  group header
    ../Analog/maxrefdes104_eval_package_v1.2.001/MAX32666_Microcontroller_Host_Example_Src_Code/: algohub_api.h algohub_config_api.h defs.h i2c_ah_sh_api.h sensorhub_api.h sensorhub_config_api.h sh_comm.h
    ./: mxc_config.h mxc_delay.h
